# Keil uVision project LPT230_gcc.uvprojx, settings and files
target LPT230 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: lpt230_gcc
  AfterMake: ../tools/arm-none-eabi-objcopy -O binary ./lpt230_gcc.elf ./lpt230_gcc.bin
  AfterMake: ../tools/LPB100_IMG_Tools.exe LPB230 lzma  ../tools/bootloader.bin lpt230_gcc.bin ./lpt230_gcc_image.bin ./lpt230_gcc_upgrade.bin
  group src
    ../sdk/4.13/libs/: startup_LPBX3GCC.S
    ../src/: app_main.c app_main.h httpd.c httpd.h user_flash.c user_flash.h user_function.c user_function.h user_gpio.c user_gpio.h user_mdns.c user_mdns.h user_power.c user_power.h user_rtc.c user_rtc.h user_udp.c user_udp.h
  group libs
    ../src/cJSON/: cJSON.c cJSON.h
