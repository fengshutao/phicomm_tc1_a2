# Keil uVision project LPBx30Example_gcc.uvprojx, settings and files
target LPT230 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: lpt230_example
  AfterMake: ../../tools/arm-none-eabi-objcopy -O binary ./lpt230_example.elf ./lpt230_example.bin
  AfterMake: ../../tools/LPB100_IMG_Tools.exe LPB230 lzma  ../../tools/bootloader.bin lpt230_example.bin ./lpt230_example_image.bin ./lpt230_example_upgrade.bin
  group src
    ../../sdk/4.13/libs/: startup_LPBX3GCC.S
    ../at/: attest.c
    ../file/: filetest.c
    ../mqtt/: mqtttest.c mqtt.c
    ../netcallback/: callbacktest.c
    ../socket/: sockettest.c
    ../ssl/: ssltest.c
    ../thread/: threadtest.c
    ../timer/: timertest.c
    ../uart/: uarttest.c
    ../uflash/: uflashtest.c
    ../update/: updatetest.c
    ../upnp/: upnptest.c
    ../websocket/: websockettest.c
    ../wifi/: wifitest.c
    ../httpsd/: httpsdtest.c httpsd.c
    ../mqtt_ssl/: mqtt_ssl.c mqtt_ssltest.c
    ../mqtt_ssl/MQTT/: mqtt_api.c mqttlib.c
    ../json/: cJSON.c jsontest.c
    ../gpio/: gpiotest.c
    ../pwm/: pwm_test.c
    ../ali_iot/: ali_iot_mqtt.c ali_iot_test.c
    ../sniffer/: sniffertest.c
    ../spi/: spi_eflash.c spitest.c
    ../mdns/: mdnstest.c
    ../smtp/: smtp.c smtptest.c
    ../hi_Link/: hi_link_test.c hi_link_test.c
    ../../thirdpartylib/hilinksdk/: hilink_device.c hilink_device_sdk.c hilink_ota.c
    ../httpd/: httpd.c httpdtest.c
