# Keil uVision project LPBx30_joylink.uvprojx, settings and files
target LPT230 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: LPBx30
  AfterMake: arm-none-eabi-objcopy -O binary ./LPBx30.elf ./LPBx30.bin
  AfterMake: ../../tools/LPB100_IMG_Tools.exe LPB230 lzma  ../../tools/bootloader.bin LPBx30.bin ./LPBx30_image.bin ./LPBx30_upgrade.bin
  group src
    ../../sdk/4.13/libs/: startup_LPBX3GCC.S
    ./: joylink_demo.c
    ../../thirdpartylib/JingDong/: Demo_Main.c jdota.c jdservice.c jdsmart.c jutils.c nodeCache.c packets.c
    ../../thirdpartylib/JingDong/auth/: crc.c uECC.c joylink_aes.c
    ../../thirdpartylib/JingDong/joylink_smnt/: joylink_smnt.c
    ../../thirdpartylib/JingDong/jsmn/: jsmn.c json_generator.c json_wrappers.c joylink_auth_uECC.c
    ../../thirdpartylib/JingDong/json/: cJSON.c joylink_json.c
    ../../thirdpartylib/JingDong/config/: joylink_probe.c joylink_thunder_slave_sdk.c
    ../../thirdpartylib/JingDong/softap/: joylink_cloud_log.c joylink_dev_active.c joylink_softap.c joylink_softap_start.c
  group HFservice
    ../../thirdpartylib/HFService/: custom_util.c HFService_downstream.c HFService_helper.c HFService_localprocess.c HFService_upstream.c protocol.c
